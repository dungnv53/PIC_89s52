# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ./DELAY/: delay.c
    ./DS1820/: ds18b20.c
    ./LCD1602/: lcd1602.c
    ./MTP/: mtp4x4.c
    ./UART/: uart.c
    ./ds1302/: ds1302.c
    ./KEY/: key.c
